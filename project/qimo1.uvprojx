# Keil uVision project qimo1.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: qimo1
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\key;.\LCD1602;.\lpc11xx;.\temp;.\UART
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group user
    ./user/: main.c
  group key
    ./key/: Key.c
  group UART
    ./UART/: UART.c
  group temp
    ./temp/: temp.c
  group LCD1602
    ./LCD1602/: LCD1602.c
  group lpc11xx
    ./lpc11xx/: startup_LPC11xx.s system_LPC11xx.c
